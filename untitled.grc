options:
  parameters:
    generate_options: qt_gui
    id: gnubbe
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '940000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./gnubbe.bin
    type: float
    vlen: '2048'
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '2048'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: '60000000'
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    bw0: '30000000'
    center_freq0: center_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: bladerf
    overall_gain0: '0'
    samp_rate: '60000000'
    type: fc32
  states: {}

connections:
- [logpwrfft_x_0, '0', blocks_file_sink_0, '0']
- [soapy_source_0, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
